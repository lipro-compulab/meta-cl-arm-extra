FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

PR .= ".1"
